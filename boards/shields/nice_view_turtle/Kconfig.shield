## boards/shields/nice_view_turtle/Kconfig.shield
```kconfig
config SHIELD_NICE_VIEW_TURTLE
    def_bool $(shields_list_contains,nice_view_turtle)
```
